# Keil uVision project 2606736780.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2606736780 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Libaray\System;.\Libaray\Hardware;.\Libaray\System
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Hardware
    ./Libaray/Hardware/: Device.c smg.c key.c uart.c sonic.c
  group System
    ./Libaray/System/: timer.c delay.c
